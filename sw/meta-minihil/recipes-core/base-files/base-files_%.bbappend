# Set custom hostname for MiniHIL board
hostname = "minihil"
